//------------------------------------------------------------------------------------------------------------------
#include "Processor.h"
//------------------------------------------------------------------------------------------------------------------
void Processor::process(void)
{
     for (int idx = 0; idx < PROCESSPR_MAX_ITEMS; idx++)
     {
          if (proc_items[idx] != 0)
          {
              proc_items[idx]();
          }
     }
}

//------------------------------------------------------------------------------------------------------------------
void Processor::init(void)
{
    memset(proc_items, 0, sizeof(proc_items));
}
//------------------------------------------------------------------------------------------------------------------
void Processor::add(ProcHandleVoid ptr)
{
     for (int idx = 0; idx < PROCESSPR_MAX_ITEMS; idx++)
     {
          if (proc_items[idx] == 0)
          {
              proc_items[idx] = ptr;
              break;
          }
     }
}
//------------------------------------------------------------------------------------------------------------------
void Processor::del(ProcHandleVoid ptr)
{
     for (int idx = 0; idx < PROCESSPR_MAX_ITEMS; idx++)
     {
          if (proc_items[idx] == ptr)
          {
              proc_items[idx] = 0;
              break;
          }
     }
}
//------------------------------------------------------------------------------------------------------------------
